# Keil uVision project freertos-weather-clock.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: freertos-weather-clock
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD,LV_CONF_INCLUDE_SIMPLE
  c include: ..\Firmware\cmsis\core;..\Firmware\cmsis\device;..\Firmware\driver\inc;..\App;..\Driver;..\Common;..\Third_lib;..\Third_lib\lvgl;..\Third_lib\lvgl\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ../App/: main.c weather_clock_ui.c weather_clock_font.c weather_clock_settings.c board.c font_download_demo.c
  group Driver
    ../Driver/: led.c usart1.c esp8266.c key.c encoder.c timer.c nec.c pwm.c lcd.c at24c02.c mpu6050.c w25q128.c touch.c
  group Firmware/Cmsis
    ../Firmware/cmsis/device/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Firmware/Library
    ../Firmware/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Third_Lib
    ../Third_lib/FONT/: GBK12.FON GBK16.FON GBK24.FON UNIGBK.BIN upload_fonts.cmd
  group Common
    ../Common/: delay.c uart.c font.c iic.c iic_hard.c spi.c spi_hard.c
  group LVGL
    ../Common/: lvgl_port.c
    ../Third_lib/lvgl/src/core/: lv_group.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_observer.c lv_refr.c
    ../Third_lib/lvgl/src/debugging/monkey/: lv_monkey.c
    ../Third_lib/lvgl/src/debugging/sysmon/: lv_sysmon.c
    ../Third_lib/lvgl/src/debugging/test/: lv_test_display.c lv_test_fs.c lv_test_helpers.c lv_test_indev_gesture.c lv_test_indev.c lv_test_screenshot_compare.c
    ../Third_lib/lvgl/src/debugging/vg_lite_tvg/: vg_lite_matrix.c
    ../Third_lib/lvgl/src/display/: lv_display.c
    ../Third_lib/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../Third_lib/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../Third_lib/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../Third_lib/lvgl/src/draw/dma2d/: lv_draw_dma2d_fill.c lv_draw_dma2d_img.c lv_draw_dma2d.c
    ../Third_lib/lvgl/src/draw/espressif/ppa/: lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c lv_draw_ppa.c
    ../Third_lib/lvgl/src/draw/eve/: lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_draw_eve.c lv_eve.c
    ../Third_lib/lvgl/src/draw/: lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_draw.c lv_image_decoder.c
    ../Third_lib/lvgl/src/draw/nanovg/: lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_draw_nanovg.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    ../Third_lib/lvgl/src/draw/nema_gfx/: lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_draw_nema_gfx.c lv_nema_gfx_path.c
    ../Third_lib/lvgl/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_draw_g2d.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../Third_lib/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_draw_pxp.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Third_lib/lvgl/src/draw/opengles/: lv_draw_opengles.c
    ../Third_lib/lvgl/src/draw/renesas/dave2d/: lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c lv_draw_dave2d.c
    ../Third_lib/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../Third_lib/lvgl/src/draw/snapshot/: lv_snapshot.c
    ../Third_lib/lvgl/src/draw/sw/blend/: lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb888.c lv_draw_sw_blend.c
    ../Third_lib/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../Third_lib/lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../Third_lib/lvgl/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask_rect.c lv_draw_sw_mask.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_utils.c lv_draw_sw_vector.c lv_draw_sw.c
    ../Third_lib/lvgl/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_draw_vg_lite.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../Third_lib/lvgl/src/drivers/display/drm/: lv_linux_drm_common.c lv_linux_drm_egl.c lv_linux_drm.c
    ../Third_lib/lvgl/src/drivers/display/fb/: lv_linux_fbdev.c
    ../Third_lib/lvgl/src/drivers/display/ft81x/: lv_ft81x.c
    ../Third_lib/lvgl/src/drivers/display/ili9341/: lv_ili9341.c
    ../Third_lib/lvgl/src/drivers/display/lcd/: lv_lcd_generic_mipi.c
    ../Third_lib/lvgl/src/drivers/display/nv3007/: lv_nv3007.c
    ../Third_lib/lvgl/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../Third_lib/lvgl/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../Third_lib/lvgl/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../Third_lib/lvgl/src/drivers/display/st7735/: lv_st7735.c
    ../Third_lib/lvgl/src/drivers/display/st7789/: lv_st7789.c
    ../Third_lib/lvgl/src/drivers/display/st7796/: lv_st7796.c
    ../Third_lib/lvgl/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../Third_lib/lvgl/src/drivers/evdev/: lv_evdev.c
    ../Third_lib/lvgl/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../Third_lib/lvgl/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../Third_lib/lvgl/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../Third_lib/lvgl/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
    ../Third_lib/lvgl/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_texture.c
    ../Third_lib/lvgl/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../Third_lib/lvgl/src/drivers/qnx/: lv_qnx.c
    ../Third_lib/lvgl/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
    ../Third_lib/lvgl/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../Third_lib/lvgl/src/drivers/wayland/: lv_wayland.c lv_wl_egl_backend.c lv_wl_g2d_backend.c lv_wl_keyboard.c lv_wl_pointer.c lv_wl_seat.c lv_wl_shm_backend.c lv_wl_touch.c lv_wl_window.c lv_wl_xdg_shell.c
    ../Third_lib/lvgl/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../Third_lib/lvgl/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../Third_lib/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../Third_lib/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../Third_lib/lvgl/src/font/font_manager/: lv_font_manager_recycle.c lv_font_manager.c
    ../Third_lib/lvgl/src/font/imgfont/: lv_imgfont.c
    ../Third_lib/lvgl/src/font/: lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14_aligned.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c
    ../Third_lib/lvgl/src/indev/: lv_gridnav.c lv_indev_gesture.c lv_indev_scroll.c lv_indev.c
    ../Third_lib/lvgl/src/layouts/flex/: lv_flex.c
    ../Third_lib/lvgl/src/layouts/grid/: lv_grid.c
    ../Third_lib/lvgl/src/layouts/: lv_layout.c
    ../Third_lib/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Third_lib/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Third_lib/lvgl/src/libs/bmp/: lv_bmp.c
    ../Third_lib/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Third_lib/lvgl/src/libs/freetype/: lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_freetype.c lv_ftsystem.c
    ../Third_lib/lvgl/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../Third_lib/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../Third_lib/lvgl/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../Third_lib/lvgl/src/libs/gif/: gif.c
    ../Third_lib/lvgl/src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
    ../Third_lib/lvgl/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../Third_lib/lvgl/src/libs/gltf/math/: lv_3dmath.c
    ../Third_lib/lvgl/src/libs/gstreamer/: lv_gstreamer.c
    ../Third_lib/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Third_lib/lvgl/src/libs/libpng/: lv_libpng.c
    ../Third_lib/lvgl/src/libs/libwebp/: lv_libwebp.c
    ../Third_lib/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Third_lib/lvgl/src/libs/lz4/: lz4.c
    ../Third_lib/lvgl/src/libs/nanovg/: nanovg.c
    ../Third_lib/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Third_lib/lvgl/src/libs/rle/: lv_rle.c
    ../Third_lib/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Third_lib/lvgl/src/libs/svg/: lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c lv_svg.c
    ../Third_lib/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Third_lib/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
    ../Third_lib/lvgl/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../Third_lib/lvgl/src/libs/vg_lite_driver/VGLite/: vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c vg_lite.c
    ../Third_lib/lvgl/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../Third_lib/lvgl/src/: lv_init.c
    ../Third_lib/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../Third_lib/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../Third_lib/lvgl/src/misc/cache/: lv_cache_entry.c lv_cache.c
    ../Third_lib/lvgl/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_circle_buf.c lv_color_op.c lv_color.c lv_event.c lv_fs.c lv_grad.c lv_iter.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_profiler_builtin_posix.c lv_profiler_builtin.c lv_rb.c lv_style_gen.c lv_style.c lv_templ.c lv_text_ap.c lv_text.c lv_timer.c lv_tree.c lv_utils.c
    ../Third_lib/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os_none.c lv_os.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../Third_lib/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Third_lib/lvgl/src/others/fragment/: lv_fragment_manager.c lv_fragment.c
    ../Third_lib/lvgl/src/others/translation/: lv_translation.c
    ../Third_lib/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../Third_lib/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../Third_lib/lvgl/src/stdlib/: lv_mem.c
    ../Third_lib/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../Third_lib/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../Third_lib/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../Third_lib/lvgl/src/themes/default/: lv_theme_default.c
    ../Third_lib/lvgl/src/themes/: lv_theme.c
    ../Third_lib/lvgl/src/themes/mono/: lv_theme_mono.c
    ../Third_lib/lvgl/src/themes/simple/: lv_theme_simple.c
    ../Third_lib/lvgl/src/tick/: lv_tick.c
    ../Third_lib/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../Third_lib/lvgl/src/widgets/animimage/: lv_animimage.c
    ../Third_lib/lvgl/src/widgets/arc/: lv_arc.c
    ../Third_lib/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../Third_lib/lvgl/src/widgets/bar/: lv_bar.c
    ../Third_lib/lvgl/src/widgets/button/: lv_button.c
    ../Third_lib/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../Third_lib/lvgl/src/widgets/calendar/: lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../Third_lib/lvgl/src/widgets/canvas/: lv_canvas.c
    ../Third_lib/lvgl/src/widgets/chart/: lv_chart.c
    ../Third_lib/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../Third_lib/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Third_lib/lvgl/src/widgets/gif/: lv_gif.c
    ../Third_lib/lvgl/src/widgets/image/: lv_image.c
    ../Third_lib/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../Third_lib/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../Third_lib/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../Third_lib/lvgl/src/widgets/label/: lv_label.c
    ../Third_lib/lvgl/src/widgets/led/: lv_led.c
    ../Third_lib/lvgl/src/widgets/line/: lv_line.c
    ../Third_lib/lvgl/src/widgets/list/: lv_list.c
    ../Third_lib/lvgl/src/widgets/lottie/: lv_lottie.c
    ../Third_lib/lvgl/src/widgets/menu/: lv_menu.c
    ../Third_lib/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../Third_lib/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../Third_lib/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../Third_lib/lvgl/src/widgets/roller/: lv_roller.c
    ../Third_lib/lvgl/src/widgets/scale/: lv_scale.c
    ../Third_lib/lvgl/src/widgets/slider/: lv_slider.c
    ../Third_lib/lvgl/src/widgets/span/: lv_span.c
    ../Third_lib/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../Third_lib/lvgl/src/widgets/spinner/: lv_spinner.c
    ../Third_lib/lvgl/src/widgets/switch/: lv_switch.c
    ../Third_lib/lvgl/src/widgets/table/: lv_table.c
    ../Third_lib/lvgl/src/widgets/tabview/: lv_tabview.c
    ../Third_lib/lvgl/src/widgets/textarea/: lv_textarea.c
    ../Third_lib/lvgl/src/widgets/tileview/: lv_tileview.c
    ../Third_lib/lvgl/src/widgets/win/: lv_win.c
